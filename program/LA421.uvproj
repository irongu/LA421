# Keil uVision project LA421.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: LA421 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LA421.c
  group System
    ./: STC8F.h delay.c delay.h
  group Driver
    ./: ds3231.h ds3231.c HPDL1414.h HPDL1414.C i2c.c i2c.h
